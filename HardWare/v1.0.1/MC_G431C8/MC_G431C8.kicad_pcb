# Repository zagerx/BLDC

File readme.md:

# BLDC版本说明
## v1.0.4_1
- QT波特率调整，同时支持115200 2000000
- QT工程 "处理线程无法及时处理"问题解决一部分，还需优化
- QT只有在运行状态下才能显示心跳包，待解决

## v1.0.4
- STM32G431工程
    - 波特率调整至2000000
    - QT工程增加CustomPlot模块
        - 发送频率过快，处理线程无法及时处理。待解决
        - 生成MCOM.exe文件`D:\WorkNote\BLDC\QT\project\MCOM\MCOM_V1.0.4`
    - 优化一些公共模块
## v1.0.3
- STM32G431工程
    - 增加位置模式
    - 对速度进行低通滤波
    - 开环功能
        - 支持自开环
        - 支持编码器开环
        - makefile中开启对应宏定义，使用MCOM助手，进入速度模式，启动电机
## v1.0.2
- 适配STM32G431工程
- 适配STM32F405工程
- 支持MT6816编码器
- 支持AS5600编码器
## v1.0.1
- 适配STM32G431工程
- 实现速度环，电流环闭环
## v1.0.0
- STM32F405RG工程
    - 实现速度，电流闭环
    - 通过宏定义，开环/闭环切换
    - MCOM助手配合调试PID参数
    - 发送速度指令给MCOM，MCOM正确响应
    - USER_DEBUG_NORMAL正常打印至MCOM
- MCOM助手
    - 状态指示灯闪烁
    - 速度值的Charts绘制
    - 启动/停止/目标速度/控制参数信息/PID参数设置/PID目标设置

## KiCad design HardWare/v1.0.1/MC_G431C8/MC_G431C8.kicad_pcb

Parts:
C1, C2, C16, C17, C18, C19, C44: 0.1uF; C_0603_1608Metric
C20, C21: 22pF; C_0603_1608Metric
D1: LED_Red; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J2: Conn_01x03; Molex_PicoBlade_53398-0371_1x03-1MP_P1.25mm_Vertical
J3: Conn_01x04; Molex_PicoBlade_53398-0471_1x04-1MP_P1.25mm_Vertical
J4: Conn_01x06; Molex_PicoBlade_53398-0671_1x06-1MP_P1.25mm_Vertical
J6: Conn_01x02; Molex_PicoBlade_53398-0271_1x02-1MP_P1.25mm_Vertical
R13, R14: 4.7K; R_0603_1608Metric
R15: 4.7K(1%); R_0603_1608Metric
R49, R50, R51, R52, R53, R54, R55, R56: 100R; R_0603_1608Metric
R57: 120R; R_0603_1608Metric
TP4, TP5, TP6, TP7: TestPoint_Alt; TestPoint_Pad_D1.0mm
U1: STM32G431C8; LQFP-48_7x7mm_P0.5mm
U9: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 32MHZ; Crystal_SMD_3225-4Pin_3.2x2.5mm
key_1: SW_Push; SW_SPST_CK_RS282G05A3
reset1: SW_Push; SW_SPST_CK_RS282G05A3

Connections:
+3.3VADC: C18.1, U1.20 (VREF+); also elsewhere on the board
+3V3: C16.1, C17.1, C19.1, C44.1, J3.4, J4.1, R13.1, R14.1, R15.2, U1.21 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U9.5 (VIO); also elsewhere on the board
+5V: U9.3 (VCC); also elsewhere on the board
/ADC_VBUS: TP4.1, U1.25 (PB11); also elsewhere on the board
/CAN_+: U1.33 (PA11/TIM1_CH4), U9.4 (RXD)
/CAN_-: U1.34 (PA12), U9.1 (TXD)
/CAN_N: J6.2, R57.1, U9.7 (CANH)
/CAN_P: J6.1, R57.2, U9.6 (CANL)
/DEBUG_RX: J2.3, R49.1
/DEBUG_TX: J2.2, R50.1
/ENCODER_A: U1.14 (PA6); also elsewhere on the board
/ENCODER_B: U1.15 (PA7); also elsewhere on the board
/ENCODER_Z: U1.16 (PB0); also elsewhere on the board
/KEY_01: C1.1, R13.2, U1.3 (PC14), key_1.2
/LED_01: D1.1 (K), U1.2 (PC13)
/OP_I_U: TP7.1, U1.11 (PA3); also elsewhere on the board
/OP_I_V: TP6.1, U1.10 (PA2/ADC1_CH3); also elsewhere on the board
/OP_I_W: TP5.1, U1.9 (PA1/ADC1_CH2); also elsewhere on the board
/RST: C2.1, R14.2, U1.7 (PG10/NRST), reset1.2
/SPI1_CLK: J4.3, R53.1; also elsewhere on the board
/SPI1_CS: J4.2, R54.1; also elsewhere on the board
/SPI1_MISO: J4.4, R52.1; also elsewhere on the board
/SPI1_MOSI: J4.5, R51.1; also elsewhere on the board
/SWCLK: J3.2, R55.1
/SWDIO: J3.3, R56.1
/TIM1_CH1: U1.30 (PA8/TIM1_CH1); also elsewhere on the board
/TIM1_CH1N: U1.27 (PB13); also elsewhere on the board
/TIM1_CH2: U1.31 (PA9/TIM1_CH2); also elsewhere on the board
/TIM1_CH2N: U1.28 (PB14); also elsewhere on the board
/TIM1_CH3: U1.32 (PA10/TIM1_CH3); also elsewhere on the board
/TIM1_CH3N: U1.29 (PB15); also elsewhere on the board
GND: C1.2, C2.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, J2.1, J3.1, J4.6, U1.19 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U9.2 (GND), Y1.2, Y1.4, key_1.1, reset1.1; also elsewhere on the board
unnamed: D1.2 (A), R15.1
unnamed: R56.2, U1.37 (PA13)
unnamed: R55.2, U1.38 (PA14)
unnamed: R54.2, U1.39 (PA15)
unnamed: R53.2, U1.40 (PB3)
unnamed: R52.2, U1.41 (PB4)
unnamed: R51.2, U1.42 (PB5)
unnamed: R50.2, U1.43 (PB6)
unnamed: R49.2, U1.44 (PB7)
unnamed: C20.1, U1.5 (PF0_OSC_IN), Y1.3
unnamed: C21.1, U1.6 (PF1_OSC_OUT), Y1.1
unnamed: C44.2, U9.8 (STB)

Notes on the sheet:
CAN
POWER
Driver
KEY&&LED
MCU System
CONNECT

Parts:
C22, C23, C25: 4.7uF; C_0805_2012Metric
C24: 0.1uF; C_0603_1608Metric
C26, C29, C31, C32: 1nF; C_0603_1608Metric
C27, C28, C30: 100uF/35V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C33, C34, C35, C36, C37, C38, C43: NC; C_0603_1608Metric
D2, D6, D7: 1N5819; D_SOD-123
D8, D9, D10, D11, D12, D13: BAV16W; D_SOD-123
J5: Conn_01x03; TerminalBlock_bornier-3_P5.08mm
Q2, Q3, Q4, Q5, Q6, Q8: DFN-8-1EP_6x5mm_P1.27mm_EP4x4mm
R18: 10R; R_0603_1608Metric
R19, R20, R24, R25, R30, R31: 33R; R_0603_1608Metric
R21, R22, R27, R33: 10K; R_0603_1608Metric
R23, R28, R34: 0.01R; R_2512_6332Metric
R26: 10k; R_0603_1608Metric
R29: 0.01R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32, R35, R36: 4.7K; R_0603_1608Metric
R37, R39, R45: 1K(1%); R_0603_1608Metric
R38, R40, R46: 6.8K; R_0603_1608Metric
R41, R43, R47: 4.7K(1%); R_0603_1608Metric
R42, R44, R48: 0R; R_0603_1608Metric
TP14, TP15, TP16, TP17, TP18, TP19: TestPoint_Alt; TestPoint_Pad_D1.0mm
U2: fd6288t; TSSOP-20_4.4x5mm_P0.4mm
U3: LMV324I; SSOP-14_5.3x6.2mm_P0.65mm
U8: AS5047D; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3V3: C32.1, C43.1, R35.1, U3.4 (V), U8.11 (VDD), U8.12 (VDD3V3); also elsewhere on the board
+12V: D2.2 (A), D6.2 (A), D7.2 (A), R18.1; also elsewhere on the board
+24V: C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q5.1 (S), Q5.2 (S), Q5.3 (S), Q8.1 (S), Q8.2 (S), Q8.3 (S); also elsewhere on the board
/Driver/U: C22.1, J5.3, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), Q8.9 (D), R22.2, U2.18 (VS1)
/Driver/U_CH: D9.1 (K), R20.2, TP14.1, U2.19 (HO1)
/Driver/U_CHN: D8.1 (K), R19.2, TP17.1, U2.11 (LO1)
/Driver/V: C23.1, J5.2, Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D), Q4.1 (S), Q4.2 (S), Q4.3 (S), R26.2, U2.15 (VS2)
/Driver/V_CH: D10.1 (K), R24.2, TP15.1, U2.16 (HO2)
/Driver/V_CHN: D11.1 (K), R25.2, TP18.1, U2.10 (LO2)
/Driver/W: C25.1, J5.1, Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.9 (D), Q6.1 (S), Q6.2 (S), Q6.3 (S), R32.2, U2.12 (VS3)
/Driver/W_CH: D12.1 (K), R30.2, TP16.1, U2.13 (HO3)
/Driver/W_CHN: D13.1 (K), R31.2, TP19.1, U2.9 (LO3)
/Driver/i_u: Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), Q3.9 (D), R21.2, R23.1, R38.2, U3.3 (+)
/Driver/i_v: Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q4.9 (D), R27.2, R28.1, R46.2, U3.6 (-)
/Driver/i_w: Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q6.9 (D), R33.2, R34.1, R40.2, U3.9 (-)
/ENCODER_A: U8.7 (A); also elsewhere on the board
/ENCODER_B: U8.6 (B); also elsewhere on the board
/ENCODER_Z: U8.14 (I/PWM); also elsewhere on the board
/OP_I_U: C34.2, R42.2; also elsewhere on the board
/OP_I_V: C38.2, R48.2; also elsewhere on the board
/OP_I_W: C36.2, R44.2; also elsewhere on the board
/SPI1_CLK: U8.2 (CLK); also elsewhere on the board
/SPI1_CS: U8.1 (~CS); also elsewhere on the board
/SPI1_MISO: U8.3 (MISO); also elsewhere on the board
/SPI1_MOSI: U8.4 (MOSI); also elsewhere on the board
/TIM1_CH1: U2.3 (HIN3); also elsewhere on the board
/TIM1_CH1N: U2.6 (LIN3); also elsewhere on the board
/TIM1_CH2: U2.2 (HIN2); also elsewhere on the board
/TIM1_CH2N: U2.5 (LIN2); also elsewhere on the board
/TIM1_CH3: U2.1 (HIN1); also elsewhere on the board
/TIM1_CH3N: U2.4 (LIN1); also elsewhere on the board
GND: C24.1, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C34.1, C36.1, C38.1, C43.2, R23.2, R28.2, R34.2, R36.2, R37.1, R39.1, R45.1, U2.8 (COM), U3.11 (G), U8.5 (TST), U8.13 (GND); also elsewhere on the board
unnamed: C33.2, R41.2, R42.1, U3.1
unnamed: C37.2, R47.2, R48.1, U3.7
unnamed: C22.2, D2.1 (K), U2.20 (VB1)
unnamed: C23.2, D6.1 (K), U2.17 (VB2)
unnamed: C25.2, D7.1 (K), U2.14 (VB3)
unnamed: D8.2 (A), Q3.4 (G), R19.1, R21.1
unnamed: D9.2 (A), Q8.4 (G), R20.1, R22.1
unnamed: D10.2 (A), Q2.4 (G), R24.1, R26.1
unnamed: D11.2 (A), Q4.4 (G), R25.1, R27.1
unnamed: D12.2 (A), Q5.4 (G), R30.1, R32.1
unnamed: D13.2 (A), Q6.4 (G), R31.1, R33.1
unnamed: C24.2, R18.2, U2.7 (VCC)
unnamed: C33.1, R39.2, R41.1, U3.2 (-)
unnamed: C37.1, R45.2, R47.1, U3.5 (+)
unnamed: C35.2, R43.2, R44.1, U3.8 (11)
unnamed: C35.1, R37.2, R43.1, U3.10 (+)
unnamed: R35.2, R36.1, U3.12 (+)
unnamed: R29.2, U3.13 (-), U3.14 (D_O)
Vref: R29.1, R38.1, R40.1, R46.1

Notes on the sheet:
GATE DRIVER
1.65V基准电压

Parts:
C3, C39, C40, C41, C42: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C4, C5, C8, C11, C12, C15: 0.1uF; C_0603_1608Metric
C6, C9, C13: 4.7uF; C_0805_2012Metric
C7: 1uF; C_0603_1608Metric
C10: 22nF; C_0603_1608Metric
C14: 100uF/35V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D4: LED_Red; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: B340A; D_SMA
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L1: 10uH; L_Abracon_ASPI-0630LR
Q1: MMBT3904L; SOT-23
R1: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R17: 4.7K; R_0603_1608Metric
R3, R4: 10K; R_0603_1608Metric
R5: 39K; R_0603_1608Metric
R6: 10R; R_0603_1608Metric
R7: 3.3K; R_0603_1608Metric
R8: 140K(1%); R_0603_1608Metric
R9: 10K(1%); R_0603_1608Metric
R10: 20R; R_0603_1608Metric
R11: 33K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 47K; R_0603_1608Metric
TP1, TP2, TP3: TestPoint_Alt; TestPoint_Pad_D1.0mm
U4: TL431DBZ; SOT-23
U5: SGM6232YPS8G; SOIC-8_3.9x4.9mm_P1.27mm
U6: AMS1117-3.3; SOT-223-3_TabPin2
U7: AMS1117-5.0; SOT-223-3_TabPin2

Connections:
+3.3VADC: Q1.3 (E), R1.1, TP3.1; also elsewhere on the board
+3V3: C5.1, C6.1, R2.2, TP2.1, U6.2 (VO); also elsewhere on the board
+5V: C8.1, C9.1, Q1.2 (C), R7.1, R12.1, U6.3 (VI), U7.2 (VO); also elsewhere on the board
+12V: C12.1, C13.1, R10.2, TP1.1, U7.3 (VI); also elsewhere on the board
+24V: C3.1, C4.1, C39.1, C40.1, C41.1, C42.1, J1.2, R3.1, R16.1, U5.2 (IN); also elsewhere on the board
/ADC_VBUS: R16.2, R17.1; also elsewhere on the board
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C12.2, C13.2, C14.2, C15.2, C39.2, C40.2, C41.2, C42.2, D4.1 (K), D5.2 (A), J1.1, R4.2, R5.2, R7.2, R9.2, R11.2, R17.2, U4.3 (A), U5.4 (GND), U6.1 (GND), U7.1 (GND); also elsewhere on the board
unnamed: C10.2, R5.1
unnamed: C11.1, R6.2
unnamed: C14.1, C15.1, L1.2, R8.1, R10.1
unnamed: D4.2 (A), R2.1
unnamed: C11.2, D5.1 (K)
unnamed: Q1.1 (B), R12.2, U4.1 (K)
unnamed: R1.2, R11.1, U4.2 (REF)
unnamed: R6.1, U5.1 (BS)
unnamed: C10.1, U5.6 (COMP)
unnamed: R3.2, R4.1, U5.7 (EN)
unnamed: R8.2, R9.1, U5.5 (FB)
unnamed: C7.1, U5.8 (SS)
unnamed: L1.1, U5.3 (SW)

Notes on the sheet:
LT431
DC-DC
LDO

Board: 4 copper layers, 100.0 x 50.0 mm, 152 parts (91 on the bottom side), 90 nets.

## KiCad design HardWare/v1.0.1/AS5047_DeomBoard/AS5047_DeomBoard.kicad_pcb

Parts:
C1: 1uF; C_0603_1608Metric
J1: Conn_01x06; PinHeader_1x06_P1.27mm_Horizontal
J2, J3: Conn_01x03; PinHeader_1x03_P1.27mm_Horizontal
R1, R2, R3: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: AS5047D; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3.3V: C1.2, J1.1, R4.2, U1.11 (VDD), U1.12 (VDD3V3)
/A: J2.1, U1.6 (B)
/B: J2.2, U1.7 (A)
/I/PWM: J2.3, U1.14 (I/PWM)
/U: J3.1, U1.10 (U)
/V: J3.2, U1.9 (V)
/W/PWM: J3.3, U1.8 (W/PWM)
GND: C1.1, J1.2, U1.5 (TST), U1.13 (GND)
unnamed: J1.3, R4.1, U1.1 (~CS)
unnamed: J1.4, R1.1
unnamed: J1.5, R2.1
unnamed: J1.6, R3.1
unnamed: R1.2, U1.2 (CLK)
unnamed: R2.2, U1.3 (MISO)
unnamed: R3.2, U1.4 (MOSI)

Board: 2 copper layers, 9 parts (0 on the bottom side), 15 nets, no tracks yet.

## KiCad design HardWare/STM32G431CBT6.kicad_pcb

Parts:
C1, C2, C5, C6, C7, C8, C9: 0.1uF; C_0603_1608Metric
C3, C4: 22pF; C_0603_1608Metric
D1: LED_Red; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R1, R2, R3: 4.7K(1%); R_0603_1608Metric
R4: 0R; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9: TestPoint_Small; TestPoint_Pad_D1.0mm
U1: STM32G431C8T6; LQFP-48_7x7mm_P0.5mm
Y1: 32MHZ; Crystal_SMD_3225-4Pin_3.2x2.5mm
key_1: SW_Push; SW_SPST_CK_RS282G05A3
reset1: SW_Push; SW_SPST_CK_RS282G05A3

Connections:
+3V3: C5.1, C6.1, C7.2, C8.1, C9.1, J2.4, J3.1, R1.1, R2.1, R3.2, U1.1 (VBAT), U1.20 (VREF+), U1.21 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD); also elsewhere on the board
/DEBUG_RX: J1.3, U1.44 (PB7)
/DEBUG_TX: J1.2, U1.43 (PB6)
/KEY_01: C1.1, R1.2, U1.34 (PA12), key_1.2
/LED_01: D1.1 (K), U1.2 (PC13)
/OP_I_U: U1.11 (PA3); also elsewhere on the board
/OP_I_V: U1.10 (PA2/ADC1_CH3); also elsewhere on the board
/OP_I_W: U1.9 (PA1/ADC1_CH2); also elsewhere on the board
/OP_bus+: U1.12 (PA4); also elsewhere on the board
/RST: C2.1, R2.2, U1.7 (PG10/NRST), reset1.2
/SPI1_CLK: J3.2, U1.39 (PA15)
/SPI1_CS: J3.5, U1.42 (PB5)
/SPI1_MISO: J3.3, U1.40 (PB3)
/SPI1_MOSI: J3.4, U1.41 (PB4)
/SWCLK: J2.3, U1.38 (PA14)
/SWDIO: J2.2, U1.37 (PA13)
/TIM1_CH1: TP5.1, U1.30 (PA8/TIM1_CH1); also elsewhere on the board
/TIM1_CH1N: TP8.1, U1.27 (PB13); also elsewhere on the board
/TIM1_CH2: TP4.1, U1.31 (PA9/TIM1_CH2); also elsewhere on the board
/TIM1_CH2N: TP7.1, U1.28 (PB14); also elsewhere on the board
/TIM1_CH3: TP3.1, U1.32 (PA10/TIM1_CH3); also elsewhere on the board
/TIM1_CH3N: TP6.1, U1.29 (PB15); also elsewhere on the board
/TIM_BKIN: TP9.1, U1.26 (PB12)
/VBUS_AD: U1.25 (PB11); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, J1.1, J2.1, J3.6, R4.1, U1.19 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), Y1.2, Y1.4, key_1.1, reset1.1; also elsewhere on the board
unnamed: C3.1, U1.5 (PF0_OSC_IN), Y1.3
unnamed: C4.1, U1.6 (PF1_OSC_OUT), Y1.1
unnamed: D1.2 (A), R3.1
unnamed: R4.2, U1.45 (PB8/BOOT0/SCL)
unnamed: TP1.1, U1.3 (PC14)
unnamed: TP2.1, U1.33 (PA11/TIM1_CH4)
